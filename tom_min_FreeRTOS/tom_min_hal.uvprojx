# Keil uVision project tom_min_hal.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tom_min_app +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\main;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\User;.\User\include;.\fatfs;.\Utilities\STM32_EVAL;.\Utilities\STM32_EVAL\Common;.\Utilities\STM32_EVAL\STM3210E_EVAL;.\User\SPI_FLASH;.\User\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./main/: main.c stm32f10x_it.c
    ./: retarget.c
    ./User/source/: Tom_Common_Api.c
  group core
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ./FreeRTOS/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_2.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group sdcard
    ./Utilities/STM32_EVAL/Common/: stm32_eval_sdio_sd.c
    ./Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
  group FATFS
    ./fatfs/: diskio.c ff.c
  group spi_flash
    ./User/SPI_FLASH/: spi_flash.c spi_test.c
  group hal
    ./User/hal/: hal_spi_flash.c
